inherit core-image

IMAGE_FEATURES[validitems] += " \
    tools-debug \
    ssh-server-openssh \
"
